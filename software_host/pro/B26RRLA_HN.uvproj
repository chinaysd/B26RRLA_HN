# Keil uVision project B26RRLA_HN.uvproj, settings and files
target B26RRLA_HN (MCS-51)
  device: SC92F8362B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: B26RRLA_HN +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group bsp
    ../bsp/: bsp_interrupt.c bsp_lock.c bsp_timer.c bsp_uart.c bsp_wdt.c bsp_key.c bsp_pwm.c bsp_cup.c
  group lib
    ../lib/: SC92F836xB_C.H SC92F8X6XB_HighSensitive_Lib_T1_V1.2.0.LIB S_TouchKeyCFG.C
  group TimeOut
    ../TimeOut/: TimeOut.c
